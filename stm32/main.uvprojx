# Keil uVision project main.uvprojx, settings and files
target project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ZeroRTOS\CORE;..\ZeroRTOS\MALLOC;..\ZeroRTOS\OS;.\inc;.\STM32F10x_FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group mian
    ./src/: main.c stm32f10x_it.c system_stm32f10x.c
  group fwlib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group core
    ../ZeroRTOS/CORE/: startup_stm32f10x_hd.s core_cm3.c
  group ZeroRTOS
    ../ZeroRTOS/OS/: os.c core.asm
    ../ZeroRTOS/MALLOC/: malloc.c
  group system
    ./src/: sys.c delay.c usart.c
